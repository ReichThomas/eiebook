# IAR project eie_assembler.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U2E Atmel ATSAM3U2E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eie_assembler.hex
  ILINK.IlinkOutputFile: eie_assembler.out
  ILINK.IlinkIcfFile: sam3u2c_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: AT91SAM3U4.h board_cstartup_iar.c exceptions.c exceptions.h kill_x_cycles.s main_assembler_gpio.s sam3u2c_flash.icf
